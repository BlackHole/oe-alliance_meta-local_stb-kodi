RDEPENDS_${PN}_arm += " \
    kodi-addon-inputstream-adaptive \
    "
