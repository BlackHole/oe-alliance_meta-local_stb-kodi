KODIADDONBRANCH_arm = "Leia"
SRCREV_pvr${KODIADDONPLUGIN}_arm = "a980f77dd0240ee1d18ba26d521a133b7dac46d4"