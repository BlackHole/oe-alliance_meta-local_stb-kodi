KODIADDONBRANCH_arm = "Leia"
SRCREV_pvr${KODIADDONPLUGIN}_arm = "bd71d2dbd7b0cf99b03636fa94997f8058eed2ba"
DEPENDS_append_arm = " \
	    nlohmann-json \
	"