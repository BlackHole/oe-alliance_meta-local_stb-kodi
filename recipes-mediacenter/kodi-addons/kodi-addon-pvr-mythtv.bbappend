KODIADDONBRANCH_arm = "Leia"
SRCREV_pvr${KODIADDONPLUGIN}_arm = "3f93b0de0de6135eee325591af619859cdaf0477"

SRC_URI_arm = "git://github.com/janbar/pvr.${KODIADDONPLUGIN}.git;destsuffix=pvr.${KODIADDONPLUGIN};name=pvr${KODIADDONPLUGIN};branch=${KODIADDONBRANCH}"
