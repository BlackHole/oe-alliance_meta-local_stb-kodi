PREFERRED_VERSION_kodi-platform = "17"
